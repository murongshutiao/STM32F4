# Keil uVision project F429_Template.uvprojx, settings and files
target APP1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F429 +hex
  AfterMake: fromelf --bin -o .\Objects/STM32F429.bin .\Objects\STM32F429.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,
  c include: ..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_HAL_Driver\Inc;..\User;..\User\led;..\User\BSP;..\User\Module\lwip;..\User\Module\lwip\include;..\User\Module\lwip\arch;..\User\Module\lwip\include\lwip;..\FreeRTOS\include;..\FreeRTOS\port\RVDS\ARM_CM4F;..\User\Module\lwip\apps;..\User\Module\lwip\include\lwip\apps;..\Middlewares\easylogger;..\Middlewares\easylogger\inc;..\Middlewares\xprintf\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_HAL_Driver
    ../Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_fmc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_usb.c stm32f4xx_hal_can.c
  group BSP
    ../User/BSP/led/: bsp_led.c
    ../User/BSP/button/: bsp_button.c
    ../User/BSP/rcc/: bsp_rcc.c
    ../User/BSP/debug/: bsp_uart_debug.c
    ../User/BSP/uart/: bsp_uart_modbus.c
    ../User/BSP/dma/: bsp_dma.c
    ../User/BSP/eeprom/: bsp_i2c_eeprom.c
    ../User/BSP/i2c/: bsp_i2c_comm.c
    ../User/BSP/flash/: bsp_spi_flash.c
    ../User/BSP/lcd/: bsp_ltdc_rgb888.c
    ../User/BSP/adc/: bsp_adc.c
    ../User/BSP/sdram/: bsp_fmc_sdram.c
    ../User/BSP/tim/: bsp_timer.c
    ../User/BSP/sdio/: bsp_sdio_sd.c sdio_test.c
    ../User/BSP/internalflash/: bsp_internalflash.c
    ../User/BSP/rtc/: bsp_rtc.c
    ../User/BSP/can/: bsp_can_comm.c
    ../User/BSP/iap/: iap.c
    ../User/BSP/eth/: bsp_eth.c
  group COMMON
    ../User/Common/: common.c
  group FATFS
    ../User/Module/FATFS/: diskio.c ff.c Fatfs_ExtFlash_user.c
    ../User/Module/FATFS/option/: cc936.c
  group Middleware
    ../User/Module/MultiTimer/: multi_timer.c multi_timer_user.c
    ../User/Module/MultiButton/: multi_button.c multi_button_user.c
    ../Middlewares/xprintf/src/: xprintf.c xprintf_port.c
  group USER
    ../User/: main.c stm32f4xx_it.c board.c
  group DOC
    ../Doc/: readme.txt
  group Letter-Shell
    ../User/Module/letter_shell/src/: shell.c shell_cmd_list.c shell_companion.c shell_ext.c
    ../User/Module/letter_shell/port/: shell_port.c
  group SENSOR
    ../User/Sensor/mpu6050/: bsp_i2c_mpu6050.c
  group LwIP/api
    ../User/Module/lwip/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LwIP/core
    ../User/Module/lwip/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../User/Module/lwip/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group LwIP/netif
    ../User/Module/lwip/netif/: bridgeif.c bridgeif_fdb.c ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c slipif.c zepif.c
  group LwIP/arch
    ../User/Module/lwip/arch/ethernetif/: ethernetif.c
    ../User/Module/lwip/arch/: lwip_eth_user.c sys_arch.c
  group LwIP/Web
    ./web/: web.c web.inp
    ../User/Module/lwip/apps/http/: fs.c httpd.c
    ../User/Module/lwip/arch/lwip_app/: httpd_cgi_ssi.c
  group FreeRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/port/MemMang/: heap_4.c
  group ELOG/src
    ../Middlewares/easylogger/src/: elog.c elog_async.c elog_buf.c elog_utils.c
  group ELOG/port
    ../Middlewares/easylogger/port/: elog_port.c
